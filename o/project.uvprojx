# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL
  c misc: --diag_suppress=870
  c include: ..\st_core;..\st_lib;..\os_src;..\library;..\main;..\usb
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group st_core
    ../st_core/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group st_lib
    ../st_lib/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group os_src
    ../os_src/: atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOSConfig.h heap_4.c list.c list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h task.h tasks.c timers.c timers.h
  group library
    ../library/: U_USART1.c U_USART1.h
  group main
    ../main/: Func.c Func.h main.c Shadow.c Shadow.h BaseFunc.c BaseFunc.h
    ../st_core/: startup_stm32f10x_md.s
  group USB
    ../usb/: hw_config.h platform_config.h usb_conf.h usb_core.c usb_core.h usb_def.h usb_desc.h usb_init.c usb_init.h usb_int.c usb_int.h usb_istr.h usb_lib.h usb_mem.c usb_mem.h usb_prop.h usb_pwr.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
